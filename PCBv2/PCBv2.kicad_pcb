# Repository SergioGasquez/DAQ

File README.md:

# Data Acquisition System

Here you can find everything about my final degree proyect, all the code, desings and PCB files can be found on the repository. Here is a summary of the proyect:

## General Diagram
The general diagram of the DAQ could be simplified as:

Collected data will be avaliable in a [web developed for this purpose](https://tfg-sergio-gasquez.onlosant.com/) (An amazing IoT platform!)

## Prototypes
Two prototypes have been developed:

## Analog Conditioning
There are two analog conditioning parts:
- Amplifier

-Reductor

Also, the MAX743 is used to power all the OP Amps in his typical configuration.

## Final product

This is the end result:

The thesis can be also found in the repo, but sadly had to write it in spanish. If you have any doubt feel free to ask without hessitation!

## License
Copyright (c) 2017 Sergio Gasquez Licensed under the MIT license.

## KiCad design PCBv2/PCBv2.kicad_pcb

Parts:
C1, C5: 0.01uF; Cap
C2: 0.1uF; Cap
C3: 10uF; Cap
C4: 1uFC; Cap
C6, C7, C11, C12, C13, C14, C15, C16, C17, C18, C19: 100nF; Cap
C8, C9, C10: 100uF; Cap
D1, D2: D_Schottky; R-C-L-D
D3, D4, D5: LM4040; D_DO-15_P2.54mm_Vertical_AnodeUp
IC1: MAX743CWE+; DIP-16_W7.62mm; Manufacturer_Part_Number MAX743CWE+
J1: Arduino_Mega_Header; arduino_mega_header
J2: Conn_01x10; Pin_Header_Straight_1x10_Pitch2.54mm
J3, J4, J6, J7, J8: Conn_01x08; arduino_pin_socket_8
J5: Conn_02x18_Odd_Even; Pin_Header_Straight_2x18_Pitch2.54mm
J9, J10, J11, J12, J13: Screw_Terminal_01x03; ScrewTerminal
J14: Conn_01x05; Pin_Header_Straight_1x05_Pitch2.54mm
L1, L2: 100uH; R-C-L-D
R1: 68k; R-C-L-D
R2: 18k; R-C-L-D
R3, R9, R20: 22k; R-C-L-D
R4, R8, R12, R16: 100k; R-C-L-D
R5, R14: 200k; R-C-L-D
R6: 51k; R-C-L-D
R7, R15: 47k; R-C-L-D
R10, R11, R18, R23: 10k; R-C-L-D
R13, R19: 50k; R-C-L-D
R17: 270k; R-C-L-D
R21: 1k; R-C-L-D
R22: 330; R-C-L-D
U1: NOKIA5110; Nokia5110
U2: RTC; SDShield
U3: SDshield; SDShield
U4: ADG408; DIP-16_W7.62mm
U5: ADC
U6, U7, U8, U9, U10: LM358; DIP-8_W7.62mm
U11: DAC
U12: DG419; DIP-8_W7.62mm

Connections:
/3.3V: J1.4 (3.3V), J6.4, U1.6 (VCC)
/5V: C2.1, C8.1, C19.2, D5.1 (K), IC1.3 (AV+), IC1.4 (V+(1)), IC1.5 (V+(2)), IC1.12 (V+(3)), IC1.13 (V+(4)), J1.5 (5V), J1.60 (5V), J5.36, J6.5, L1.1, R20.2, R21.2, U1.7 (BL), U2.2 (VCC), U3.5 (VCC), U5.1 (VDD), U10.8 (V+), U11.6 (VDD), U12.5 (VCC)
/ADC-A2: J12.2, U5.9 (A2)
/ADC-A3: J12.3, U5.10 (A3)
/ARDU-A8: J1.17 (AD8), J8.1, J9.1
/ARDU-A9: J1.18 (AD9), J8.2, J9.2
/ARDU-A10: J1.19 (AD10), J8.3, J9.3
/ARDU-A11: J1.20 (AD11/TXD3), J8.4, J10.1
/D1: U4.8 (D), U6.3 (+)
/DAC-VO: R12.2, U11.1 (VOUT)
/E1: U4.4 (S1)
/E2: U4.5 (S2)
/E3: J11.3, U4.6 (S3)
/E4: J12.1, U4.7 (S4)
/E5: J10.2, U4.12 (S5)
/E6: J10.3, U4.11 (S6)
/E7: J11.1, U4.10 (S7)
/E8: J11.2, U4.9 (S8)
/E-AMPLI: J13.1, U12.8 (A)
/GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.1, C8.2, C9.2, C10.2, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, D3.2 (A), D4.2 (A), D5.2 (A), IC1.2 (AGND), IC1.11 (12/~15), IC1.14 (GND), J1.6 (GND), J6.6, J14.4, J14.5, L2.2, R2.2, R6.1, R7.2, R13.1, R15.2, R18.2, R22.2, U1.8 (GND), U2.1 (GND), U3.6 (GND), U4.14 (GND), U5.2 (GND), U8.3 (+), U10.4 (V-), U11.5 (GND), U12.3 (GND)
/PIN2: J1.71 (PWM2/2), J3.6, U1.1 (RST)
/PIN3: J1.72 (PWM3/3), J3.5, U1.2 (CE)
/PIN4: J1.73 (SS1/PWM4/SD-CS/4), J3.4, U1.3 (DC)
/PIN5: J1.74 (PWM5/5), J3.3, U1.4 (DIN)
/PIN6: J1.75 (PWM6/6), J3.2, U1.5 (CLK)
/PIN9: J1.78 (PWM9/9), J2.9, J14.3
/PIN10: J1.79 (SS0/PWM10/ETH-CS/10), J2.8, J14.2
/PIN11: J1.80 (PWM11/11), J2.7, J14.1
/PIN31: J1.55 (PIN31), J5.26, U12.6 (A/B)
/PIN35: J1.53 (PIN35), J5.22, U4.2 (EN)
/PIN39: J1.51 (PIN39), J5.18, U4.1 (A0)
/PIN41: J1.50 (PIN41), J5.16, U4.16 (A1)
/PIN43: J1.49 (PIN43), J5.14, U4.15 (A2)
/PIN50: J1.27 (PIN50), J5.5, U3.4 (MOSO)
/PIN51: J1.45 (PIN51), J5.6, U3.3 (MOSI)
/PIN52: J1.26 (PIN52/AD14/RXD3), J5.3, U3.2 (SCK)
/PIN53: J1.44 (CANTX1/IO/PIN53), J5.4, U3.1 (CS)
/SCL: J1.61 (SCL0-3/TWCK1/21), J1.86 (SCL1/TWCK0), J2.1, J4.8, U2.4 (SCL), U5.3 (SCL), U11.4 (SCL)
/SDA: J1.62 (SDA0-3/TWD1/20), J1.85 (SDA1/TWD0), J2.2, J4.7, U2.3 (SDA), U5.4 (SDA), U11.3 (SDA)
/SMU2: J13.2, R23.2, U10.2 (-)
/SMU-IN: J13.3, U12.2 (B)
/SMU-OUT: R23.1, U5.7 (A0), U10.1
/VO-AMPLI: R19.1, U9.1, U12.1 (COM)
/VO-REDU: R8.1, U5.8 (A1), U7.1
unnamed: C1.1, IC1.1 (CC+)
unnamed: C3.1, IC1.6 (VREF)
unnamed: C4.1, IC1.7 (SS)
unnamed: C5.1, IC1.8 (CC-)
unnamed: C15.2, R12.1, R13.2, R14.1, U8.5 (+)
unnamed: C16.2, R17.1, U9.3 (+)
unnamed: D1.2 (A), IC1.15 (LX+), L1.2
unnamed: D2.1 (K), IC1.10 (LX-), L2.1
unnamed: D3.1 (K), R3.1, R5.2
unnamed: D4.1 (K), R9.2, R10.2
unnamed: R1.1, R2.1, U6.5 (+)
unnamed: R1.2, U6.1, U6.2 (-)
unnamed: R4.1, R5.1, R6.2, U7.3 (+)
unnamed: R4.2, U6.6 (-), U6.7
unnamed: R7.1, R8.2, U7.2 (-)
unnamed: R10.1, R11.2, U8.2 (-)
unnamed: R11.1, R14.2, U8.1
unnamed: R15.1, R16.2, U8.6 (-)
unnamed: R16.1, R17.2, U8.7
unnamed: R18.1, R19.2, U9.2 (-)
unnamed: R21.1, R22.1, U10.3 (+)

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
Board: 2 copper layers, 165.1 x 110.0 mm, 76 parts (1 on the bottom side), 65 nets.

File PCBv2/Gerber/PCBv2-BoM.csv:

"Id";"Designator";"Package";"Quantity";"Designation";"Supplier and ref";
1;"U2";"SDShield";1;"RTC";;;
2;"J1";"arduino_mega_header";1;"Arduino_Mega_Header";;;
3;"U5";"ADC";1;"ADC";;;
4;"J2";"Pin_Header_Straight_1x10_Pitch2.54mm";1;"Conn_01x10";;;
5;"J3,J4,J7,J8,J6";"arduino_pin_socket_8";5;"Conn_01x08";;;
6;"J5";"Pin_Header_Straight_2x18_Pitch2.54mm";1;"Conn_02x18_Odd_Even";;;
7;"U1";"Nokia5110";1;"NOKIA5110";;;
8;"D3,D4,D5";"D_DO-15_P2.54mm_Vertical_AnodeUp";3;"LM4040";;;
9;"J9,J10,J11,J12,J13";"ScrewTerminal";5;"Screw_Terminal_01x03";;;
10;"R5,R14";"R-C-L-D";2;"200k";;;
11;"R6";"R-C-L-D";1;"51k";;;
12;"R7,R15";"R-C-L-D";2;"47k";;;
13;"R8,R12,R16,R4";"R-C-L-D";4;"100k";;;
14;"R9,R20,R3";"R-C-L-D";3;"22k";;;
15;"R10,R11,R18,R23";"R-C-L-D";4;"10k";;;
16;"R13,R19";"R-C-L-D";2;"50k";;;
17;"R17";"R-C-L-D";1;"270k";;;
18;"R21";"R-C-L-D";1;"1k";;;
19;"R22";"R-C-L-D";1;"330";;;
20;"U4";"DIP-16_W7.62mm";1;"ADG408";;;
21;"IC1";"DIP-16_W7.62mm";1;"MAX743CWE+";;;
22;"C1,C5";"Cap";2;"0.01uF";;;
23;"C2";"Cap";1;"0.1uF";;;
24;"C3";"Cap";1;"10uF";;;
25;"C4";"Cap";1;"1uFC";;;
26;"C6,C7,C11,C12,C13,C14,C15,C16,C17,C18,C19";"Cap";11;"100nF";;;
27;"C8,C9,C10";"Cap";3;"100uF";;;
28;"D1,D2";"R-C-L-D";2;"D_Schottky";;;
29;"L1,L2";"R-C-L-D";2;"100uH";;;
30;"R1";"R-C-L-D";1;"68k";;;
31;"R2";"R-C-L-D";1;"18k";;;
32;"U6,U7,U8,U9,U10";"DIP-8_W7.62mm";5;"LM358";;;
33;"U11";"DAC";1;"DAC";;;
34;"U12";"DIP-8_W7.62mm";1;"DG419";;;
35;"U3";"SDShield";1;"SDshield";;;
36;"J14";"Pin_Header_Straight_1x05_Pitch2.54mm";1;"Conn_01x05";;;

## KiCad design PCB/DAQ.kicad_pcb

File PCB/readme.md:

# PCB

## Schematic 

## Layout

Parts:
C1: 100uF; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
C2: 0.1uF; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
C3: 10uF; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
C4: 1uF; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
C5, C6, C7, C8, C10, C11, C12, C13: 100nF; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
C9: 100nF; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
CC+1: 0.01uF; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
CC-1: 0.01uF; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
CF+1: 100uF; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
CF-1: 100uF; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
D1, D2: LM4040; R-C-L-D
DX+1: D_Schottky; D_A-405_P12.70mm_Horizontal
DX-1: D_Schottky; D_A-405_P12.70mm_Horizontal
IC1: MAX743CWE+; DIP-16_W7.62mm; Manufacturer_Part_Number MAX743CWE+
J1: Arduino_Mega_Header; arduino_mega_header
J2, J8: Conn_01x07; Pin_Header_Straight_1x07_Pitch2.54mm
J3, J4, J7: Conn_01x08; Pin_Header_Straight_1x08_Pitch2.54mm
J5: Conn_02x18_Counter_Clockwise; Pin_Header_Straight_2x18_Pitch2.54mm
J6: Conn_01x10; Pin_Header_Straight_1x10_Pitch2.54mm
J9: Screw_Terminal_01x08
LX+1: 100uH; L_Axial_L9.5mm_D4.0mm_P12.70mm_Horizontal_Fastron_SMCC
LX-1: 100uH; L_Axial_L9.5mm_D4.0mm_P12.70mm_Horizontal_Fastron_SMCC
R1: 68k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 18k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 22k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4, R8: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5: 200k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R6: 51k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R7: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R9: 22K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R10, R11, R17: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R12, R16: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R13: 200K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R14: 57K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R15: 47K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R18: 50k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R19: 270k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1: SDshield; SDShield
U2: RTC; SDShield
U3: ADC
U4: NOKIA5110; Nokia5110
U5: DAC
U6, U7, U8, U9: LM358; DIP-8_W7.62mm
U10: ADG408; DIP-16_W7.62mm

Connections:
/3.3V: J1.4 (3.3V), J2.3, U4.6 (VCC)
/5V: C1.1, C2.2, IC1.3 (AV+), IC1.4 (V+(1)), IC1.5 (V+(2)), IC1.12 (V+(3)), IC1.13 (V+(4)), J1.5 (5V), J1.60 (5V), J2.4, J5.2, LX+1.1, U1.5 (VCC), U2.2 (VCC), U3.1 (VDD), U4.7 (BL), U5.6 (VDD)
/+15V: C5.2, C8.2, C10.2, C12.2, CF+1.1, DX+1.1 (K), IC1.16 (FB+), R3.1, R9.1, U6.8 (V+), U7.8 (V+), U8.8 (V+), U9.8 (V+), U10.13 (VDD)
/-15V: C6.1, C7.2, C11.2, C13.2, CF-1.1, DX-1.2 (A), IC1.9 (FB-), U6.4 (V-), U7.4 (V-), U8.4 (V-), U9.4 (V-), U10.3 (VSS)
/D: U6.3 (+), U10.8 (D)
/DACVo: R12.2, U5.1 (VOUT)
/EN: J1.52 (PIN37), J5.18, U10.2 (EN)
/GND: C1.2, C5.1, C6.2, C7.1, C8.1, C9.2, C10.1, C11.1, C12.1, C13.1, CF+1.2, CF-1.2, D1.2 (A), D2.2 (A), IC1.11 (12/~15), IC1.14 (GND), J1.6 (GND), J1.83 (GND), J2.5, J5.36, J6.4, LX-1.2, R2.2, R6.1, R7.2, R14.2, R15.2, R17.2, U1.6 (GND), U2.1 (GND), U3.2 (GND), U4.8 (GND), U5.5 (GND), U8.3 (+), U10.14 (GND)
/PIN2: J7.6
/PIN3: J1.72 (PWM3/3), J7.5, U4.1 (RST)
/PIN4: J1.73 (SS1/PWM4/SD-CS/4), J7.4, U4.2 (CE)
/PIN5: J1.74 (PWM5/5), J7.3, U4.3 (DC)
/PIN6: J1.75 (PWM6/6), J7.2, U4.4 (DIN)
/PIN7: J1.76 (PWM7/7), J7.1, U4.5 (CLK)
/PIN50: J1.27 (PIN50), J5.30, U1.4 (MOSO)
/PIN51: J1.45 (PIN51), J5.32, U1.3 (MOSI)
/PIN52: J1.26 (PIN52/AD14/RXD3), J5.34, U1.2 (SCK)
/PIN53: J1.44 (CANTX1/IO/PIN53), U1.1 (CS)
/S1: J9.1, U10.4 (S1)
/S2: J9.2, U10.5 (S2)
/S3: J9.3, U10.6 (S3)
/S4: J9.4, U10.7 (S4)
/S5: J9.5, U10.12 (S5)
/S6: J9.6, U10.11 (S6)
/S7: J9.7, U10.10 (S7)
/S8: J9.8, U10.9 (S8)
/SCL: J1.61 (SCL0-3/TWCK1/21), J1.86 (SCL1/TWCK0), J6.1, J8.7, U2.4 (SCL), U3.3 (SCL), U5.4 (SCL)
/SDA: J1.62 (SDA0-3/TWD1/20), J1.85 (SDA1/TWD0), J6.2, J8.6, U2.3 (SDA), U3.4 (SDA), U5.3 (SDA)
/VinADC: R8.1, U3.8 (A1), U7.1
/m_A0: J1.51 (PIN39), J5.20, U10.1 (A0)
/m_A1: J1.50 (PIN41), J5.22, U10.16 (A1)
/m_A2: J1.49 (PIN43), J5.24, U10.15 (A2)
unnamed: C2.1, C3.1, C4.1, CC+1.2, CC-1.2, IC1.2 (AGND)
unnamed: C3.2, IC1.6 (VREF)
unnamed: C4.2, IC1.7 (SS)
unnamed: CC+1.1, IC1.1 (CC+)
unnamed: CC-1.1, IC1.8 (CC-)
unnamed: D1.1 (K), R3.2, R5.2
unnamed: D2.1 (K), R9.2, R10.2
unnamed: DX+1.2 (A), IC1.15 (LX+), LX+1.2
unnamed: DX-1.1 (K), IC1.10 (LX-), LX-1.1
unnamed: R1.1, U6.1, U6.2 (-)
unnamed: R1.2, R2.1, U6.5 (+)
unnamed: R4.1, R5.1, R6.2, U7.3 (+)
unnamed: R4.2, U6.6 (-), U6.7
unnamed: R7.1, R8.2, U7.2 (-)
unnamed: R10.1, R11.2, U8.2 (-)
unnamed: R11.1, R13.2, U8.1
unnamed: R12.1, R13.1, R14.1, U8.5 (+)
unnamed: R15.1, R16.2, U8.6 (-)
unnamed: R17.1, R18.2, U9.2 (-)

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
Board: 2 copper layers, 164.0 x 140.0 mm, 61 parts (3 on the bottom side), 45 nets.

## Commit log

2018-02-27 First Version
2018-03-11 Change of the structure and add PCB schematic
2018-03-12 PCB Improvement
2018-03-16 PCB Improvements
2018-03-16 Add ground plane,max743 and started analogic conditioner
2018-03-20 Analog Conditioner added int PCB layout
2018-03-20 Add RTC3231 code
2018-03-20 Changed RTC Module
2018-04-03 Changed RTC Module and sepparated tabs for modules
2018-04-03 Add fileName to name the SD file with the date
2018-04-03 Changed RTC module on PCB
2018-04-05 Changes on GPRS module
2018-04-05 Add simulations of the analog part after the DAC
2018-04-05 Improvements on the PCB
2018-04-06 Changes on simulations
2018-04-10 Added analog part of DAC to PCB
2018-04-17 Analog parts of the PCB upgraded
2018-04-18 PCB Upgraded and screens of the DAC analog
2018-04-19 Tiny changes on RTC
2018-04-24 Code modulation and PCB improvements. Multiplexer added
2018-04-25 Implemented way to recognize adchannels being used
2018-05-04 Start of LaTeX proyect and few improvements
2018-05-14 Added SMU,changes on Latex and new simulations
2018-05-19 New version of PCB
2018-05-20 Added photos of the prototype and changed the PCB
2018-05-23 Changes on PCB and pins of LCD
2018-05-29 Added GPRS communications and lots of changes on the main code!
2018-06-04 Added pwr pin of the SIM900 and documentation made
2018-06-05 Changes on PCB track width and small track changes
2018-06-09 Added output via terminal and voltage sweep for I/V curves with the SMU
2018-06-12 Updated configuration and changes on images for latex
2018-06-13 Added some missing images for the latex thesis and small changes in code
2018-06-16 Reorganized some directories, added the thesis pdf and latex files
2018-06-16 Updated some datasheets
2018-06-16 Add a readme on PCB
2018-06-16 Create LICENSE
2018-06-23 Added Slides folder
